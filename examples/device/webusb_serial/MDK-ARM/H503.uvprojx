# Keil uVision project H503.uvprojx, settings and files
target H503 (6220000::V6.22::ARMCLANG)
  device: STM32H503CBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: H503
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: HSE_VALUE=8000000U USE_HAL_DRIVER CFG_TUSB_MCU=OPT_MCU_STM32H5 BOARD_STM32H503CUSTOM CFG_TUSB_DEBUG=0 LOGGER_RTT SEGGER_RTT_MODE_DEFAULT=SEGGER_RTT_MODE_NO_BLOCK_SKIP
  c include: ..\..\..\..\hw\bsp\stm32h5\boards\stm32h503custom;..\..\..\..\lib\CMSIS_5\CMSIS\Core\Include;..\..\..\..\hw\mcu\st\cmsis_device_h5\Include;..\..\..\..\hw\mcu\st\stm32h5xx_hal_driver\Inc;..\..\..\..\hw\bsp\stm32h5;..\..\..\..\src;..\..\..\..\lib\SEGGER_RTT\RTT;..\src;..\..\..\..\hw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../../../../hw/mcu/st/cmsis_device_h5/Source/Templates/arm/: startup_stm32h503xx.s
  group Application/User/Core
    ../src/: main.c usb_descriptors.c
  group Drivers/CMSIS
    ../../../../hw/mcu/st/cmsis_device_h5/Source/Templates/: system_stm32h5xx.c
  group tnyusb/stm32_fsdev
    ../../../../src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
  group STM32H5xx_hal
    ../../../../hw/mcu/st/stm32h5xx_hal_driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c
  group tinyusb/board
    ../../../../hw/bsp/stm32h5/: family.c
    ../../../../hw/bsp/: board.c
  group tinyusb
    ../../../../src/: tusb.c
    ../../../../src/common/: tusb_fifo.c
  group tinyusb/device
    ../../../../src/device/: usbd.c usbd_control.c
  group tinyusb/cdc
    ../../../../src/class/cdc/: cdc_device.c
    ../../../../src/class/vendor/: vendor_device.c
  group SEGGER_RTT
    ../../../../lib/SEGGER_RTT/RTT/: SEGGER_RTT.c
